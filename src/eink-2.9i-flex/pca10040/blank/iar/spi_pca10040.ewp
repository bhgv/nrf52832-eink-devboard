# IAR project spi_pca10040.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nRF52832-xxAA NordicSemi nRF52832-xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: BOARD_PCA10040; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52; NRF52832_XXAA; NRF52_PAN_74; SWI_DISABLE0
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\delay; ..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\components\libraries\memobj; ..\..\..\..\..\..\components\libraries\ringbuf; ..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..; ..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\external\segger_rtt; ..\..\..\..\..\..\integration\nrfx; ..\..\..\..\..\..\integration\nrfx\legacy; ..\..\..\..\..\..\modules\nrfx; ..\..\..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\..\modules\nrfx\mdk; ..\config; $PROJ_DIR$; User\e-Paper; User\GUI; User\XBM\fonts
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\delay; ..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\components\libraries\memobj; ..\..\..\..\..\..\components\libraries\ringbuf; ..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..; ..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\external\segger_rtt; ..\..\..\..\..\..\integration\nrfx; ..\..\..\..\..\..\integration\nrfx\legacy; ..\..\..\..\..\..\modules\nrfx; ..\..\..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\..\modules\nrfx\mdk; ..\config
  OBJCOPY.OOCOutputFile: spi_pca10040.hex
  ILINK.IlinkOutputFile: spi_pca10040.elf
  ILINK.IlinkIcfFile: spi_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../: main.c main.h xbm_font.h
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group Board Support
    ../../../../../../components/libraries/bsp/: bsp.c
  group e-paper
    ../../../User/e-Paper/: EPD_2in7.c EPD_2in7.h ImageData.c ImageData.h
  group gui
    ../../../User/GUI/: GUI_Paint.c GUI_Paint.h
  group None
    ../../../../../../modules/nrfx/mdk/: iar_startup_nrf52.s system_nrf52.c
  group nRF_Drivers
    ../../../../../../integration/nrfx/legacy/: nrf_drv_spi.c nrf_drv_uart.c
    ../../../../../../modules/nrfx/drivers/src/: nrfx_gpiote.c nrfx_spi.c nrfx_spim.c nrfx_uart.c nrfx_uarte.c
    ../../../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_IAR.c
  group xbm
    ../../../User/XBM/fonts/: ACLine_[100]_xbm_font.c ACLine_[100]_xbm_font.h Alexander_[100]_xbm_font.c Alexander_[100]_xbm_font.h ALLEGRON_[100]_xbm_font.c ALLEGRON_[100]_xbm_font.h Bender_[100]_xbm_font.c Bender_[100]_xbm_font.h BNHRDFAN_[100]_xbm_font.c BNHRDFAN_[100]_xbm_font.h BNHRDFAN_[50]_xbm_font.c BNHRDFAN_[50]_xbm_font.h BNHRDMBI_[100]_xbm_font.c BNHRDMBI_[100]_xbm_font.h BNHRDMOB_[100]_xbm_font.c BNHRDMOB_[100]_xbm_font.h BNKGOTHM_[100]_xbm_font.c BNKGOTHM_[100]_xbm_font.h BNKGOTHM_[60]_xbm_font.c BNKGOTHM_[60]_xbm_font.h CaviarDreams_[100]_xbm_font.c CaviarDreams_[100]_xbm_font.h DINNextW1G_Light_[127]_xbm_font.c DINNextW1G_Light_[127]_xbm_font.h DINNextW1G_Light_[58]_xbm_font.c DINNextW1G_Light_[58]_xbm_font.h gnyrwn971_[100]_xbm_font.c gnyrwn971_[100]_xbm_font.h GOST_A__[100]_xbm_font.c GOST_A__[100]_xbm_font.h GOST_A__[62]_xbm_font.c GOST_A__[62]_xbm_font.h Lasco_[100]_xbm_font.c Lasco_[100]_xbm_font.h LCD_[100]_xbm_font.c LCD_[100]_xbm_font.h LCD_[124]_xbm_font.c LCD_[124]_xbm_font.h LEngineer_[100]_xbm_font.c LEngineer_[100]_xbm_font.h NotoSans_[100]_xbm_font.c NotoSans_[100]_xbm_font.h OpenSans_[100]_xbm_font.c OpenSans_[100]_xbm_font.h Raleway_[100]_xbm_font.c Raleway_[100]_xbm_font.h RobotoCondensed_[100]_xbm_font.c RobotoCondensed_[100]_xbm_font.h TMVinograd_[100]_xbm_font.c TMVinograd_[100]_xbm_font.h TMVinograd_[70]_xbm_font.c TMVinograd_[70]_xbm_font.h Ubuntu_[100]_xbm_font.c Ubuntu_[100]_xbm_font.h
